VERSION ""

NS_ :
	NS_DESC_
	CM_
	BA_DEF_
	BA_
	VAL_
	CAT_DEF_
	CAT_
	FILTER
	BA_DEF_DEF_
	EV_DATA_
	ENVVAR_DATA_
	SGTYPE_
	SGTYPE_VAL_
	BA_DEF_SGTYPE_
	BA_SGTYPE_
	SIG_TYPE_REF_
	VAL_TABLE_
	SIG_GROUP_
	SIG_VALTYPE_
	SIGTYPE_VALTYPE_
	BO_TX_BU_
	BA_DEF_REL_
	BA_REL_
	BA_SGTYPE_REL_
	SG_MUL_VAL_

BS_:

BU_: ENGINE VDC

BO_ 123 ENGINE_DATA: 8 ENGINE
 SG_ ENGINE_Torque : 0|16@1+ (0.1,0) 0|6553.5 "Nm" VDC
 SG_ ENGINE_RPM : 16|16@1+ (0.25,0) 0|16383.75 "rpm" VDC
